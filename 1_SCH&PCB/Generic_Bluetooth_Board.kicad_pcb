# Repository GeneRAD/BLUENRG1_Generic_Bluetooth_Board

File README.md:

# BLUENRG1_Generic_Bluetooh_Board
A bluetooth generic development board with BLUENRG-1.

## KiCad design 1_SCH&PCB/Generic_Bluetooth_Board.kicad_pcb

Parts:
AE1: Antenna_Shield; 2.4GHz-INVERTED-F-ANTENNA
BT1: Battery_Cell; BatteryHolder_Keystone_1058_1x2032
C1: 100pF; C_0402
C2: 150nF; C_0402
C3, C7, C16, C18: 1uF; C_0402
C4, C8, C17, C19, C23, C26, C27: 100nF; C_0402
C5, C6, C21, C22: 15pF; C_0402
C9, C12: 56pF; C_0402
C10, C20: 1.3pF; C_0402
C11, C13, C15: 0.5pF; C_0402
C14: C; C_0402
C24: 4.7uF; C_0402
C25: 10uF; C_0402
D1: LED; LED_0603
J1: Conn_01x02_Female; Pin_Header_Straight_1x02_Pitch2.00mm_SMD_Pin1Right
J2: Conn_01x05_Male; Pin_Header_Straight_1x05_Pitch2.00mm_SMD_Pin1Right
J3, J5, J6: Conn_01x03_Male; Pin_Header_Straight_1x03_Pitch2.00mm_SMD_Pin1Left
J4: Conn_01x04_Male; Pin_Header_Straight_1x04_Pitch2.00mm_SMD_Pin1Left
L1: 10uH; R_0805
L2, L3: 1.3nH; R_0402_NoSilk
L4: 5.6nH; R_0402_NoSilk
L5: 2.4nH; R_0402_NoSilk
L6: 4.7uH; Inductor_1212
R1, R13: 309k; R_0402
R2, R3, R4, R11: 1k; R_0402
R5, R6, R10: 0R; R_0402
R7, R16, R17, R18: 10k; R_0402
R8, R9, R14, R15: R; R_0402
R12: 9.76k; R_0402
SW1: SW_DIP_x08; SW_DIP_x8_W5.08mm_Slide_Copal_CHS-A
U1: BlueNRG-1; QFN-32-1EP_5x5mm_Pitch0.5mm
U2: LMT84DCK; SOT-353_SC-70-5
U3: MCP1640BCH; SOT-23-6_Handsoldering
U4: AT25xxx; TSSOP-8_4.4x3mm_Pitch0.65mm
Y1: Crystal_Small; Crystal_SMD_3215-2pin_3.2x1.5mm
Y2: Crystal_GND24_Small; Crystal_SMD_3225-4pin_3.2x2.5mm_HandSoldering

Connections:
+3V3: BT1.1 (+), C7.1, C8.1, C16.1, C17.1, C18.1, C19.1, C24.1, J1.2, J2.1, J4.1, L6.1, R1.2, R2.1, R3.1, R5.1, R7.1, R10.1, R16.2, R17.2, R18.2, U1.6 (VBAT3), U1.19 (VBAT2), U1.24 (VBAT1), U3.3 (EN), U3.6 (VIN), U4.8 (VCC)
+5V: C25.1, R6.1, R12.1, U3.5 (VOUT)
/ADC1_IN: C26.1, J3.2, R8.1, R11.1
/ADC2_IN: J5.2, R14.1
/CLK: SW1.6, U1.12 (DIO0), U4.6 (SCK)
/CS: R18.1, SW1.7, U1.11 (DIO1), U4.1 (~CS)
/GRP_ADD_0: SW1.1, U1.3 (DIO8)
/GRP_ADD_1: SW1.2, U1.4 (DIO7)
/GRP_ADD_2: SW1.3, U1.5 (DIO6)
/GRP_ADD_3: SW1.4, U1.9 (DIO3), U4.2 (MISO)
/I2C1_SCL: J4.3, R2.2, U1.30 (DIO12)
/I2C1_SDA: J4.2, R3.2, U1.29 (DIO13)
/MOSI: SW1.8, U1.10 (DIO2), U4.5 (MOSI)
/NUM_UNT_3: SW1.5, U1.13 (ANATST0/DIO14)
/PWM_0: J6.2, U1.7 (DIO5)
/PWM_1: J6.1, U1.8 (DIO4)
/RESET: C27.1, J2.2, R16.1, U1.25 (RSETN)
/SR_PWR: C23.1, R4.1, R10.2, U1.32 (DIO11), U2.4 (Vdd)
/SW_TCK: J2.4, U1.2 (DIO9)
/SW_TDIO: J2.3, U1.1 (DIO10)
/VCC_S: J3.3, J5.3, R5.2, R6.2
GND: AE1.2 (Shield), BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D1.1 (K), J1.1, J2.5, J3.1, J4.4, J5.1, J6.3, R9.2, R13.1, R15.2, U1.31 (TEST), U1.33 (EP), U2.1 (GND), U2.2 (GND), U2.5 (GND), U3.2 (GND), U4.4 (GND), Y2.2, Y2.4
unnamed: AE1.1 (A), C15.1, L4.2
unnamed: C1.1, C2.1, U1.28 (VDD1V2)
unnamed: C3.1, C4.1, L1.2, U1.27 (SMPSFILT2)
unnamed: C5.1, U1.23 (SXTAL0), Y1.1
unnamed: C6.1, U1.22 (SXTAL1), Y1.2
unnamed: C9.2, L2.2
unnamed: C10.1, L3.1, L5.2
unnamed: C10.2, C11.1, L2.1, U1.21 (RF0)
unnamed: C11.2, C20.1, L5.1, U1.20 (RF1)
unnamed: C12.1, C14.1, L4.1
unnamed: C12.2, C13.1, L3.2
unnamed: C21.1, U1.17 (FXTAL1), Y2.3
unnamed: C22.1, U1.18 (FXTAL0), Y2.1
unnamed: D1.2 (A), R4.2
unnamed: L1.1, U1.26 (SMPSFILT1)
unnamed: L6.2, U3.1 (SW)
unnamed: R1.1, SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16
unnamed: R8.2, R9.1, U1.15 (ADC1)
unnamed: R11.2, U2.3 (OUT)
unnamed: R12.2, R13.2, U3.4 (VFB)
unnamed: R7.2, R14.2, R15.1, U1.16 (ADC2)
unnamed: R17.1, U4.3 (~WP), U4.7 (~HOLD)

Board: 2 copper layers, 34.5 x 36.8 mm, 67 parts (1 on the bottom side), 44 nets.

## Commit log

2019-08-01 Initial commit.
